# Keil uVision project LoRaV1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LoRaV1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F411xE,DEBUG
  c include: .\CORE;.\HARDWARE;.\SYSTEM\chip;.\SYSTEM\sys;.\USER;.\SYSTEM\delay;.\SYSTEM\DBuart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./USER/: test.c
  group CORE
    ./CORE/: core_cm4..c startup_stm32f411xe.s
  group SYSTEM
    ./SYSTEM/chip/: system_stm32f4xx.c stm32f4xx_it.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/DBuart/: DBuart.c
  group HARDWARE
    ./HARDWARE/: led.c
